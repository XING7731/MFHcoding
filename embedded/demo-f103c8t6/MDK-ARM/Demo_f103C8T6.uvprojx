# Keil uVision project Demo_f103C8T6.uvprojx, settings and files
target Demo_f103C8T6 (6090000::V6.9::.\ARMCA)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Demo_f103C8T6 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\system\Adc;..\system\Delay;..\system\Iic;..\system\Spi;..\system\Sys;..\system\timer;..\system\Usart;..\system\wdg;..\system\init;..\system\Flash;..\Hardware\CH2O;..\Hardware\esp8266;..\Hardware\Udp;..\Hardware\air780;..\Hardware\wind_direction;..\Hardware\wind_speed;..\Hardware\NBBC26;..\Hardware\MLX90614ESF;..\Hardware\bmp280;..\Hardware\18B20;..\Hardware\dht11;..\Hardware\hc05;..\Hardware\tcs3200;..\Hardware\Voltage_measure;..\Hardware\Current_measure;..\Show;..\Protocol\cJSON;..\Hardware\atgm336h;..\system\algorithm;..\Hardware\water_level;..\Hardware\noise_level;..\Hardware\dust_level;..\Hardware\heart_level;..\Hardware\Sudhumi_level;..\Hardware\PH_level;..\Hardware\hc_sr04;..\Hardware\ds1302;..\Hardware\rc522;..\Hardware\as608;..\Hardware\adxl345;..\Hardware\max30102;..\Hardware\hx711;..\Hardware\pressure_level;..\Hardware\motors;..\Hardware\rays_level;..\Hardware\Ina219;..\Hardware\speed;..\system\keypad;..\Hardware\esp32;..\Show\LCD1602;..\Hardware\mpu6050;..\Show\SD1306;..\Hardware\mq_level;..\Hardware\jq8900
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group System
    ../system/Sys/: Sys.c
    ../system/Iic/: iic.c
    ../system/Adc/: adc.c
    ../system/Spi/: Spi.c
    ../system/timer/: timer.c
    ../system/Usart/: usart.c
    ../system/wdg/: wdg.c
    ../system/Delay/: delay.c
    ../system/init/: init.c
    ../system/algorithm/: algo.c
    ../system/Flash/: flash.c
    ../system/keypad/: keypad.c
  group Show
    ../Show/SD1306/: SD1306.c
  group Hardware
    ../Hardware/ds1302/: ds1302.c
    ../Hardware/rc522/: rc522.c
    ../Hardware/motors/: motors.c
software components: CMSIS:CORE 5.1.1
